# Keil uVision project Project.uvprojx, settings and files
target STM32469I_DISCO (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F469NIHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IRAM(0x20000000-0x2004FFFF) IRAM2(0x10000000-0x2000FFFF) IROM(0x8000000-0x81FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: STM32469I_DISCO
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F469xx,USE_STM32F469I_DISCOVERY
  c misc: --C99
  c include: ..\Inc;D:\STM32Cube_F4\Drivers\CMSIS\Device\ST\STM32F4xx\Include;D:\STM32Cube_F4\Drivers\STM32F4xx_HAL_Driver\Inc;..\..\00_BSP;..\..\..\Library;..\..\..\Middlewares\FreeRTOS\Source\portable\RVDS\ARM_CM4F;..\..\..\Middlewares\FreeRTOS\Source\include;..\..\..\Middlewares\FreeRTOS\Source\CMSIS_RTOS
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x50000
  link misc: --diag_suppress=L6329
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group Drivers/STM32F4xx_HAL_Driver
    D:/STM32Cube_F4/Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_gpio.c stm32f4xx_hal_ltdc_ex.c stm32f4xx_hal_sd.c stm32f4xx_hal_sram.c stm32f4xx_hal_cortex.c stm32f4xx_hal_ltdc.c stm32f4xx_hal_dma_ex.c stm32f4xx_ll_fmc.c stm32f4xx_ll_fsmc.c stm32f4xx_hal_dma.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal.c stm32f4xx_hal_rtc.c stm32f4xx_hal_spi.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_tim.c stm32f4xx_hal_i2c.c stm32f4xx_hal_uart.c stm32f4xx_ll_sdmmc.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_usart.c stm32f4xx_hal_rcc.c stm32f4xx_hal_dma2d.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_dsi.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_sdram.c
  group Drivers/BSP/Components
    ../../00_BSP/: cs43l22.c ft6x06.c otm8009a.c
  group Drivers/BSP/STM32469I_Discovery
    ../../00_BSP/: stm32469i_discovery_ts.c stm32469i_discovery_sdram.c stm32469i_discovery_lcd.c stm32469i_discovery.c
  group FreeRTOS
    ../../../Middlewares/FreeRTOS/Source/: timers.c queue.c event_groups.c list.c croutine.c tasks.c
    ../../../Middlewares/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../../../Middlewares/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
    ../../../Middlewares/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
  group Library
    ../../../Library/: fifo.c uart.c libPDMFilter_CM4_Keil.lib
  group Application/User
    ../Src/: stm32f4xx_it.c stm32f4xx_hal_msp.c main.c
    ../../00_BSP/: stm32f469_system.c stm32f469_uart.c
    ./: startup_stm32f469xx.s
software components: CMSIS:CORE 4.1.0
