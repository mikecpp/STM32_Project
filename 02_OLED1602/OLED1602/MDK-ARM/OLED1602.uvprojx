# Keil uVision project OLED1602.uvprojx, settings and files
target STM32412G_DISCOVERY (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F412ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IRAM(0x20000000-0x2003FFFF) IROM(0x08000000-0x080FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: STM32412G_DISCOVERY
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F412Zx,USE_HAL_DRIVER,USE_STM32412G_DISCOVERY
  c misc: --C99
  c include: ..\inc;D:\STM32Cube_F4\Drivers\CMSIS\Device\ST\STM32F4xx\Include;D:\STM32Cube_F4\Drivers\CMSIS\Include;D:\STM32Cube_F4\Drivers\STM32F4xx_HAL_Driver\Inc;D:\STM32Cube_F4\Drivers\BSP\STM32412G-Discovery;D:\STM32Cube_F4\Drivers\BSP\Components\Common;..\..\..\00_BSP;..\..\..\00_LIB\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x40000
  link misc: --diag_suppress=L6329
  group Startup
    ./: startup_stm32f723xx.s startup_stm32f412zx.s
  group CMSIS
    ../Src/: system_stm32f7xx.c system_stm32f4xx.c
  group BSP
    D:/STM32Cube_F7/Drivers/BSP/STM32F723E-Discovery/: stm32f723e_discovery.c
    ../../../00_BSP/: stm32f723_system.c stm32f412_system.c stm32f412_uart.c stm32_i2c.c
    D:/STM32Cube_F4/Drivers/BSP/STM32412G-Discovery/: stm32412g_discovery.c
  group User
    ../Src/: main.c stm32f7xx_it.c stm32f4xx_it.c
    ../../../00_LIB/src/: uart.c fifo.c i2c.c oled1602.c
  group STM32F4xx_HAL_Driver
    D:/STM32Cube_F4/Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_ll_fsmc.c stm32f4xx_hal_sram.c stm32f4xx_hal_uart.c
  group STM32F7xx_HAL_Driver
    D:/STM32Cube_F7/Drivers/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal.c stm32f7xx_hal_cortex.c stm32f7xx_hal_dma.c stm32f7xx_hal_dma_ex.c stm32f7xx_hal_gpio.c stm32f7xx_hal_i2c.c stm32f7xx_hal_i2c_ex.c stm32f7xx_hal_rcc.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_sdram.c stm32f7xx_hal_uart.c stm32f7xx_ll_fmc.c stm32f7xx_hal_pwr.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_sram.c
target STM32F723E_DISCOVERY (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F723IEKx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.9.0
  cpu: IRAM(0x20000000,0x40000) IROM(0x08000000,0x80000) IROM2(0x00200000,0x80000) CPUTYPE("Cortex-M7") FPU3(SFPU) CLOCK(12000000) ELITTLE
  output: STM32F723E_DISCOVERY
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F723xx,USE_STM32F723E_DISCOVERY
  c misc: --C99
  c include: ..\Inc;D:\STM32Cube_F7\Drivers\CMSIS\Device\ST\STM32F7xx\Include;D:\STM32Cube_F7\Drivers\CMSIS\Include;D:\STM32Cube_F7\Drivers\STM32F7xx_HAL_Driver\Inc;D:\STM32Cube_F7\Drivers\BSP\STM32F723E-Discovery;D:\STM32Cube_F7\Drivers\BSP\Components\Common;..\..\..\00_BSP;..\..\..\00_LIB\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT5: ROM 0x200000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x40000
  link misc: --diag_suppress=L6329
software components: CMSIS:CORE 5.0.1
