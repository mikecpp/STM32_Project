# Keil uVision project Fire.uvprojx, settings and files
target STM32412G_DISCOVERY (6100001::V6.10.1::.\ARMCLANG)
  device: STM32F412ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IRAM(0x20000000-0x2003FFFF) IROM(0x08000000-0x080FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: STM32412G_DISCOVERY
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: STM32F412Zx,USE_HAL_DRIVER,USE_STM32412G_DISCOVERY
  c include: ..\inc;D:\STM32Cube_F4\Drivers\CMSIS\Device\ST\STM32F4xx\Include;D:\STM32Cube_F4\Drivers\CMSIS\Include;D:\STM32Cube_F4\Drivers\STM32F4xx_HAL_Driver\Inc;..\..\..\00_BSP;..\..\..\..\Library;..\..\..\..\..\Fire\inc
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x40000
  link misc: --diag_suppress=L6329
  group Startup
    ../Src/: startup_stm32f412zx.s
  group CMSIS
    ../Src/: system_stm32f4xx.c
  group STM32F4xx_HAL_Driver
    D:/STM32Cube_F4/Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_ll_fsmc.c stm32f4xx_hal_sram.c stm32f4xx_hal_uart.c stm32f4xx_hal_spi.c
  group BSP
    ../../../00_BSP/: stm32f412_system.c stm32_i2c.c
  group Library
    ../../../../Library/: uart.c fifo.c
  group Fire
    ../../../../../Fire/lib/: FireSsd1306.cpp FireLcd.cpp font8.c font12.c font16.c font20.c font24.c
    ../../../../../Fire/platform/stm32/: FireI2c.cpp
  group User
    ../Src/: stm32f4xx_it.c
    ./: main.cpp
software components: CMSIS:CORE 5.1.2
