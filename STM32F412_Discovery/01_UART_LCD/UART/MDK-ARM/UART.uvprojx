# Keil uVision project UART.uvprojx, settings and files
target STM32412G_DISCOVERY (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F412ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IRAM(0x20000000-0x2003FFFF) IROM(0x08000000-0x080FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: STM32412G_DISCOVERY
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F412Zx,USE_HAL_DRIVER,USE_STM32412G_DISCOVERY
  c misc: --C99
  c include: ..\inc;D:\STM32Cube_F4\Drivers\CMSIS\Device\ST\STM32F4xx\Include;D:\STM32Cube_F4\Drivers\CMSIS\Include;D:\STM32Cube_F4\Drivers\STM32F4xx_HAL_Driver\Inc;..\..\..\00_BSP;..\..\..\..\Library
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x40000
  link misc: --diag_suppress=L6329
  group Startup
    ../Src/: startup_stm32f412zx.s
  group CMSIS
    ../Src/: system_stm32f4xx.c
  group STM32F4xx_HAL_Driver
    D:/STM32Cube_F4/Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_ll_fsmc.c stm32f4xx_hal_sram.c stm32f4xx_hal_uart.c stm32f4xx_hal_spi.c
  group BSP
    ../../../00_BSP/: stm32f412_system.c stm32412g_discovery_lcd.c stm32412g_discovery.c ls016b8uy.c st7789h2.c
  group Library
    ../../../../Library/: uart.c fifo.c
  group User
    ../Src/: main.c stm32f4xx_it.c
software components: CMSIS:CORE 5.0.1
